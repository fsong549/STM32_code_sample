# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\USER;..\FWLib\inc;..\CMSIS;..\MY\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group MY
    ../MY/LED/: led.c
    ../MY/delay/: delay.c
    ../MY/key/: key.c
    ../MY/timer/: timer.c
    ../MY/beep/: beep.c
    ../MY/usart/: usart.c
    ../MY/adc/: adc.c
    ../MY/tft/: lcd.c
    ../MY/24cxx/: 24cxx.c
    ../MY/iic/: myiic.c
    ../MY/flash/: flash.c
    ../MY/spi/: spi.c
    ../MY/can/: can.c
    ../MY/remote/: remote.c
    ../MY/ds18b20/: ds18b20.c
    ../MY/nrf24l01/: 24l01.c
    ../MY/sd/: MMC_SD.C
    ../MY/malloc/: malloc.c
